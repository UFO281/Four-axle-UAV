# Keil uVision project F.uvproj, settings and files
target F (MCS-51)
  device: STC12C5A60S2 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: F +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\..\APP\Include;..\..\Driver\Peripheral_Driver\Include;..\..\Driver\Device_Driver\Include
  group Startup
    ../../Startup/: STARTUP.A51
  group APP
    ../../APP/Source/: main.c
  group Peripheral_Driver
    ../../Driver/Peripheral_Driver/Source/: pwm.c uart.c
