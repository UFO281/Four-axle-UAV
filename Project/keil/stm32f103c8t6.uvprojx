# Keil uVision project stm32f103c8t6.uvprojx, settings and files
target four axle uav (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103c8t6 +hex
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\APP;..\..\Driver\Core;..\..\Driver\Peripheral_Driver\Include;..\..\Driver\Device_Driver\Delay;..\..\Driver\Device_Driver\Uart
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../../APP/: main.c stm32f10x_it.c
  group Device_Driver
    ../../Driver/Device_Driver/Delay/: Delay.c
    ../../Driver/Device_Driver/Uart/: usart.c
  group Peripheral_Driver
    ../../Driver/Peripheral_Driver/Source/: misc.c stm32f10x_bkp.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c
  group Core
    ../../Driver/Core/: core_cm3.c startup_stm32f10x_md.s system_stm32f10x.c
